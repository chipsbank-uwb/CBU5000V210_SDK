# Keil uVision project DFU_Bootloader.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: CBU5000V210_DSP_FP Chipsbank
  pack: Keil.CBU5000V210_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x0,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: CBU5000V210_BOOT +hex
  BeforeMake: powershell -NoProfile -ExecutionPolicy Bypass -EncodedCommand JABFAHIAcgBvAHIAQQBjAHQAaQBvAG4AUAByAGUAZgBlAHIAZQBuAGMAZQAgAD0AIAAnAFMAdABvAHAAJwAKACQAUAByAG8AZwByAGUAcwBzAFAAcgBlAGYAZQByAGUAbgBjAGUAIAA9ACAAJwBTAGkAbABlAG4AdABsAHkAQwBvAG4AdABpAG4AdQBlACcACgAkAGEAcABwAEIAaQBuAFAAYQB0AGgAIAA9ACAAJwAuAC4AXAAuAC4AXAB1AHcAYgBfAHIAbgBnAGEAbwBhAF8AZgB0AG0AXwBkAGYAdQBcAEsAZQBpAGwAXABDAEIAVQA1ADAAMAAwAFYAMgAxADAAXwBBAFAAUAAuAGIAaQBuACcACgAkAGIAbwBvAHQAcwBlAHQAdABpAG4AZwBQAGEAdABoACAAPQAgACcALgBcAEIAaQBuAEYAaQBsAGUAXABiAG8AbwB0AHMAZQB0AHQAaQBuAGcALgBiAGkAbgAnAAoAaQBmACAAKAAtAG4AbwB0ACAAKABUAGUAcwB0AC0AUABhAHQAaAAgACQAYQBwAHAAQgBpAG4AUABhAHQAaAApACkAIAB7ACAAdABoAHIAbwB3ACAAJwBBAFAAUAAgAGIAaQBuACAAbgBvAHQAIABmAG8AdQBuAGQAOgAgACcAIAArACAAJABhAHAAcABCAGkAbgBQAGEAdABoACAAfQAKAGYAdQBuAGMAdABpAG8AbgAgAEcAZQB0AC0AQwByAGMAMwAyACAAewAKACAAIAAgACAAcABhAHIAYQBtACgAWwBiAHkAdABlAFsAXQBdACAAJABCAHkAdABlAHMAKQAKACAAIAAgACAAWwBpAG4AdAA2ADQAXQAgACQAYwByAGMAIAA9ACAAMAB4AEYARgBGAEYARgBGAEYARgBMAAoAIAAgACAAIABmAG8AcgBlAGEAYwBoACAAKAAkAHYAYQBsAHUAZQAgAGkAbgAgACQAQgB5AHQAZQBzACkAIAB7AAoAIAAgACAAIAAgACAAIAAgACQAYwByAGMAIAA9ACAAKAAkAGMAcgBjACAALQBiAHgAbwByACAAWwBpAG4AdAA2ADQAXQAkAHYAYQBsAHUAZQApACAALQBiAGEAbgBkACAAMAB4AEYARgBGAEYARgBGAEYARgBMAAoAIAAgACAAIAAgACAAIAAgAGYAbwByACAAKAAkAGIAaQB0ACAAPQAgADAAOwAgACQAYgBpAHQAIAAtAGwAdAAgADgAOwAgACQAYgBpAHQAKwArACkAIAB7AAoAIAAgACAAIAAgACAAIAAgACAAIAAgACAAaQBmACAAKAAoACQAYwByAGMAIAAtAGIAYQBuAGQAIAAxACkAIAAtAG4AZQAgADAAKQAgAHsACgAgACAAIAAgACAAIAAgACAAIAAgACAAIAAgACAAIAAgACQAYwByAGMAIAA9ACAAKAAoACgAJABjAHIAYwAgAC0AcwBoAHIAIAAxACkAIAAtAGIAeABvAHIAIAAwAHgARQBEAEIAOAA4ADMAMgAwAEwAKQAgAC0AYgBhAG4AZAAgADAAeABGAEYARgBGAEYARgBGAEYATAApAAoAIAAgACAAIAAgACAAIAAgACAAIAAgACAAfQAgAGUAbABzAGUAIAB7AAoAIAAgACAAIAAgACAAIAAgACAAIAAgACAAIAAgACAAIAAkAGMAcgBjACAAPQAgACgAKAAkAGMAcgBjACAALQBzAGgAcgAgADEAKQAgAC0AYgBhAG4AZAAgADAAeABGAEYARgBGAEYARgBGAEYATAApAAoAIAAgACAAIAAgACAAIAAgACAAIAAgACAAfQAKACAAIAAgACAAIAAgACAAIAB9AAoAIAAgACAAIAB9AAoAIAAgACAAIAByAGUAdAB1AHIAbgAgACgAKAAtAGIAbgBvAHQAIAAkAGMAcgBjACkAIAAtAGIAYQBuAGQAIAAwAHgARgBGAEYARgBGAEYARgBGAEwAKQAKAH0ACgBmAHUAbgBjAHQAaQBvAG4AIABXAHIAaQB0AGUALQBVADMAMgAgAHsACgAgACAAIAAgAHAAYQByAGEAbQAoAFsAYgB5AHQAZQBbAF0AXQAgACQAQgB1AGYAZgBlAHIALAAgAFsAaQBuAHQAXQAgACQATwBmAGYAcwBlAHQALAAgAFsAdQBpAG4AdAAzADIAXQAgACQAVgBhAGwAdQBlACkACgAgACAAIAAgAFsAYgB5AHQAZQBbAF0AXQAgACQAYgB5AHQAZQBzACAAPQAgAFsAQgBpAHQAQwBvAG4AdgBlAHIAdABlAHIAXQA6ADoARwBlAHQAQgB5AHQAZQBzACgAJABWAGEAbAB1AGUAKQAKACAAIAAgACAAWwBBAHIAcgBhAHkAXQA6ADoAQwBvAHAAeQAoACQAYgB5AHQAZQBzACwAIAAwACwAIAAkAEIAdQBmAGYAZQByACwAIAAkAE8AZgBmAHMAZQB0ACwAIAA0ACkACgB9AAoAJABhAHAAcABCAHkAdABlAHMAIAA9ACAAWwBTAHkAcwB0AGUAbQAuAEkATwAuAEYAaQBsAGUAXQA6ADoAUgBlAGEAZABBAGwAbABCAHkAdABlAHMAKAAkAGEAcABwAEIAaQBuAFAAYQB0AGgAKQAKACQAYQBwAHAAUwBpAHoAZQAgAD0AIABbAHUAaQBuAHQAMwAyAF0AJABhAHAAcABCAHkAdABlAHMALgBMAGUAbgBnAHQAaAAKACQAYQBwAHAAQwByAGMAIAA9ACAAWwB1AGkAbgB0ADMAMgBdACgAKABHAGUAdAAtAEMAcgBjADMAMgAgAC0AQgB5AHQAZQBzACAAJABhAHAAcABCAHkAdABlAHMAKQApAAoAJABhAHAAcABWAGUAcgBzAGkAbwBuACAAPQAgAFsAdQBpAG4AdAAzADIAXQAxAAoAJABiAG8AbwB0AHMAZQB0AHQAaQBuAGcAIAA9ACAATgBlAHcALQBPAGIAagBlAGMAdAAgAGIAeQB0AGUAWwBdACAAMwA0ADQACgBXAHIAaQB0AGUALQBVADMAMgAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACAANAAgADAACgBXAHIAaQB0AGUALQBVADMAMgAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACAAOAAgADAAeAAwADAAMAAwADUAMAAwADAACgBXAHIAaQB0AGUALQBVADMAMgAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACAAMQAyACAAMAB4ADAAMAAwADAAMAAwADAAMAAKAFcAcgBpAHQAZQAtAFUAMwAyACAAJABiAG8AbwB0AHMAZQB0AHQAaQBuAGcAIAAxADYAIAAkAGEAcABwAFMAaQB6AGUACgBXAHIAaQB0AGUALQBVADMAMgAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACAAMgAwACAAJABhAHAAcABDAHIAYwAKAFcAcgBpAHQAZQAtAFUAMwAyACAAJABiAG8AbwB0AHMAZQB0AHQAaQBuAGcAIAAyADQAIAAkAGEAcABwAFYAZQByAHMAaQBvAG4ACgBXAHIAaQB0AGUALQBVADMAMgAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACAAMgA4ACAAMQAKACQAYwByAGMARABhAHQAYQAgAD0AIABOAGUAdwAtAE8AYgBqAGUAYwB0ACAAYgB5AHQAZQBbAF0AIAAoACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnAC4ATABlAG4AZwB0AGgAIAAtACAANAApAAoAWwBBAHIAcgBhAHkAXQA6ADoAQwBvAHAAeQAoACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACwAIAA0ACwAIAAkAGMAcgBjAEQAYQB0AGEALAAgADAALAAgACQAYwByAGMARABhAHQAYQAuAEwAZQBuAGcAdABoACkACgAkAGQAYQB0AGEAQwByAGMAIAA9ACAAWwB1AGkAbgB0ADMAMgBdACgAKABHAGUAdAAtAEMAcgBjADMAMgAgAC0AQgB5AHQAZQBzACAAJABjAHIAYwBEAGEAdABhACkAKQAKAFcAcgBpAHQAZQAtAFUAMwAyACAAJABiAG8AbwB0AHMAZQB0AHQAaQBuAGcAIAAwACAAJABkAGEAdABhAEMAcgBjAAoAWwBTAHkAcwB0AGUAbQAuAEkATwAuAEYAaQBsAGUAXQA6ADoAVwByAGkAdABlAEEAbABsAEIAeQB0AGUAcwAoACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnAFAAYQB0AGgALAAgACQAYgBvAG8AdABzAGUAdAB0AGkAbgBnACkACgBXAHIAaQB0AGUALQBPAHUAdABwAHUAdAAgACgAJwBHAGUAbgBlAHIAYQB0AGUAZAAgAGIAbwBvAHQAcwBlAHQAdABpAG4AZwAuAGIAaQBuACAAcwBpAHoAZQA9AHsAMAB9ACAAYwByAGMAPQAwAHgAewAxADoAWAA4AH0AIABhAHAAcABfAGMAcgBjAD0AMAB4AHsAMgA6AFgAOAB9ACcAIAAtAGYAIAAkAGIAbwBvAHQAcwBlAHQAdABpAG4AZwAuAEwAZQBuAGcAdABoACwAIAAkAGQAYQB0AGEAQwByAGMALAAgACQAYQBwAHAAQwByAGMAKQANAAoA
  AfterMake: cmd.exe /C copy .\Objects\CBU5000V210_BOOT.axf .\BinFile
  AfterMake: cmd.exe /C copy .\Objects\CBU5000V210_BOOT.hex .\BinFile
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOOT
  c misc: -Wno-padded -Wno-declaration-after-statement -Wno-covered-switch-default -Wno-c11-extensions -Wno-format-nonliteral -Wno-gnu-binary-literal -Wno-overlength-strings -Wno-incompatible-pointer-types-discards-qualifiers -Wno-unused-parameter -Wno-unused-variable -Wno-unused-function -Wno-unused-but-set-parameter -Wno-unused-but-set-variable -Wno-cast-qual -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-undef -Wno-missing-noreturn -Wno-implicit-float-conversion -Wno-missing-prototypes -Wno-zero-length-array -Wno-extra-semi -Wno-variadic-macros -Wno-extra-semi-stmt -Wno-macro-redefined -Wno-unsafe-buffer-usage
  c include: .\ARMCM33_DSP_FP;..\..\..\Components\Midlayer\Flash;..\..\..\Components\Midlayer\SleepDeepSleep;..\..\..\Components\DriverCpu\Inc;..\..\..\External\LibCRC\include;..\..\..\Components\Midlayer\Dfu;..\..\..\Components\SharedUtils;..\..\..\Components\Midlayer\System;..\..\..\Components\ArmCore;..\..\..\Components\ArmCore\CMSIS_6.2.0\Core\Include;..\..\..\Components\Configuration;..\..\..\Components\DriverUwb\uwb_drivers;..\..\..\Components\Algorithm;..\..\..\Components\Midlayer\Aoa
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\ARMCM33_DSP_FP\ARMCM33_ac6.sct
  group APP_CPU
    ../App/: main.c
  group Midlayer
    ../../../Components/Midlayer/Flash/: CB_flash.c
    ../../../Components/Midlayer/SleepDeepSleep/: CB_SleepDeepSleep.c
  group DriverCPU
    ../../../Components/DriverCpu/Src/: CB_crc.c CB_gpio.c CB_iomux.c CB_qspi.c CB_scr.c CB_Uart.c CB_wdt.c
  group LibCRC
    ../../../External/LibCRC/src/: crc8.c crc16.c crc32.c crcccitt.c crcdnp.c crckrmit.c crcsick.c nmea-chk.c
  group DFU
    ../../../Components/Midlayer/Dfu/: dfu_handler.c dfu_uart.c
  group SharedUtils
    ../../../Components/SharedUtils/: NonLIB_sharedUtils.c
  group memory map
    ./Listings/: CBU5000V210.map
  group BIN
    ../../uwb_rngaoa_ftm_dfu/Keil/: app_bin.s
    ./BinFile/: bootsetting_bin.s
  group Device
    ./ARMCM33_DSP_FP/: ARMCM33_ac6.sct startup_ARMCM33.c system_ARMCM33.c
