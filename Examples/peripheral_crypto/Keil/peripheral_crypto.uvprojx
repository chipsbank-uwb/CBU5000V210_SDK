# Keil uVision project peripheral_crypto.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: CBU5000V210_DSP_FP Chipsbank
  pack: Keil.CBU5000V210_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x0,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: CBU5000V210 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded -Wno-declaration-after-statement -Wno-covered-switch-default -Wno-c11-extensions -Wno-format-nonliteral -Wno-gnu-binary-literal -Wno-overlength-strings -Wno-incompatible-pointer-types-discards-qualifiers -Wno-unused-parameter -Wno-unused-variable -Wno-unused-function -Wno-unused-but-set-parameter -Wno-unused-but-set-variable -Wno-cast-qual -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-undef -Wno-missing-noreturn -Wno-implicit-float-conversion -Wno-missing-prototypes -Wno-zero-length-array -Wno-extra-semi -Wno-variadic-macros -Wno-extra-semi-stmt -Wno-macro-redefined
  c include: ..\..\..\Components\Midlayer\Aoa;..\App;..\..\..\Components\Midlayer\Aoa;..\..\..\External\FreeRTOS\Source\include;..\..\..\External\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\External\LibCRC\include;..\..\..\Components\SharedUtils;..\..\..\Components\DriverCpu\Inc;..\..\..\Components\ArmCore\CMSIS_6.2.0\Core\Include;..\..\..\Components\ArmCore;..\..\..\Components\DriverUwb\driver_uwb_V2.5\Inc;..\..\..\Components\DriverUwb;..\..\..\Components\Configuration;..\..\..\Components\Midlayer\Flash;..\..\..\Components\Midlayer\SleepDeepSleep;..\..\..\Components\Midlayer\FlashValidation;..\..\..\Components\Midlayer\System;..\..\..\Components\Security;..\..\..\Components\Algorithm;..\..\..\Components\Application;..\..\..\..\APP\code\include\application;..\..\..\Components\DriverCpu\Src;..\..\..\Components\Midlayer\UwbFramework;..\..\..\Components\DriverUwb\uwb_drivers;..\..\..\Components\DriverUwb\uwb_drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\ARMCM33_DSP_FP\ARMCM33_ac6.sct
  group APP_CPU
    ../App/: main.c app_crypto.c
    ../../../Components/Application/: app_uart.c AppSysIrqCallback.c
  group Midlayer
    ../../../Components/Midlayer/SleepDeepSleep/: CB_SleepDeepSleep.c
    ../../../Components/Midlayer/System/: CB_system.c
  group DriverCPU
    ../../../Components/DriverCpu/Src/: CB_iomux.c CB_scr.c CB_Uart.c CB_wdt.c CB_crc.c
  group DriverUWB
    ../../../Components/DriverUwb/: CB_uwb.c
  group SharedUtils
    ../../../Components/SharedUtils/: NonLIB_sharedUtils.c
  group LIB
    ../../../Libs/CB_Lib/: CBU5000V210_UWB_LIB.lib
    ../../../Libs/BLE_Lib/: CBU5000V210_REGULATED_LIB.lib
  group memory map
    ./Listings/: CBU5000V210.map
  group Device
    ./ARMCM33_DSP_FP/: ARMCM33_ac6.sct
    ../../../Components/ArmCore/Device/ARMCM33_DSP_FP/: startup_ARMCM33.c system_ARMCM33.c
