# Keil uVision project DFU_App.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: CBU5000V210_DSP_FP Chipsbank
  pack: Keil.CBU5000V210_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x0,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: CBU5000V210 +hex
  AfterMake: fromelf --bin --output ./BinFile/APP.bin ./Objects/CBU5000V210.axf
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded -Wno-declaration-after-statement -Wno-covered-switch-default -Wno-c11-extensions -Wno-format-nonliteral -Wno-gnu-binary-literal -Wno-overlength-strings -Wno-incompatible-pointer-types-discards-qualifiers -Wno-unused-parameter -Wno-unused-variable -Wno-unused-function -Wno-unused-but-set-parameter -Wno-unused-but-set-variable -Wno-cast-qual -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-undef -Wno-missing-noreturn -Wno-implicit-float-conversion -Wno-missing-prototypes -Wno-zero-length-array -Wno-extra-semi -Wno-variadic-macros -Wno-extra-semi-stmt -Wno-macro-redefined -Wno-infinite-recursion -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-unsafe-buffer-usage
  c include: ..\App;..\..\..\External\FreeRTOS\Source\include;..\..\..\External\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\External\LibCRC\include;..\..\..\Components\SharedUtils;..\..\..\Components\DriverCpu\Inc;..\..\..\Components\ArmCore\CMSIS_5.8.0\Core\Include;..\..\..\Components\ArmCore;..\..\..\Components\DriverUwb\driver_uwb_V2.5\Inc;..\..\..\Components\DriverUwb;..\..\..\Components\Configuration;..\..\..\Components\Midlayer\Flash;..\..\..\Components\Midlayer\SleepDeepSleep;..\..\..\Components\Midlayer\Commtrx;..\..\..\Components\Midlayer\FlashValidation;..\..\..\Components\Midlayer\Aoa;..\..\..\Components\Midlayer\Pdoa;..\..\..\Components\Midlayer\Dstwr;..\..\..\Components\Midlayer\System;..\..\..\Components\Security;..\..\..\Components\Algorithm;..\..\..\Components\Application;..\..\..\..\APP\code\include\application;..\..\..\Components\BleController\driver_ble_controller\Inc;..\..\..\Components\Midlayer\Ble;..\..\..\Components\Midlayer\Dfu;..\..\..\External\BLE_Host\include;..\..\..\External\BLE_Host\include\nimble;..\..\..\Components\DriverUwb\uwb_drivers;..\..\..\Components\Cmdparser;..\..\..\Components\Midlayer\Ftm;..\..\..\Components\Midlayer\UwbFramework
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\ARMCM33_DSP_FP\ARMCM33_ac6.sct
  group APP_CPU
    ../App/: main.c AppDemo.c
  group Dfu
    ../../../Components/Midlayer/Dfu/: dfu_blesvc.c dfu_handler.c dfu_uart.c
    ../../../Components/Cmdparser/: cmd_parser_uart.c
  group BLEHost
    ../../../External/BLE_Host/source/: addr.c aes_encrypt.c ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_dtm.c ble_eatt.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_hs.c ble_hs_adv.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_misc.c ble_hs_mqueue.c ble_hs_periodic_sync.c ble_hs_pvcy.c ble_hs_shutdown.c ble_hs_startup.c ble_hs_stop.c ble_hs_utils.c ble_ibeacon.c ble_iso.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_sm.c ble_sm_alg.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_config.c ble_store_util.c ble_svc_gap.c ble_uuid.c cmac_mode.c ecc.c ecc_dh.c endian.c hci_h4.c mem.c nimble_port.c nimble_port_freertos.c npl_os_freertos.c os_cputime_pwr2.c os_mbuf.c os_mempool.c os_msys_init.c transport.c
  group FreeRTOS
    ../../../External/FreeRTOS/Source/: croutine.c event_groups.c freertos_evr.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../External/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../External/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group Midlayer
    ../../../Components/Midlayer/SleepDeepSleep/: CB_SleepDeepSleep.c
    ../../../Components/Midlayer/System/: CB_system.c
    ../../../Components/Midlayer/Flash/: CB_flash.c
    ../../../Components/Midlayer/UwbFramework/: CB_uwbframework.c
  group DriverCPU
    ../../../Components/DriverCpu/Src/: CB_iomux.c CB_scr.c CB_timer.c CB_Uart.c CB_wdt.c CB_efuse.c CB_crc.c CB_qspi.c
  group DriverUWB
    ../../../Components/DriverUwb/: CB_uwb.c
  group SharedUtils
    ../../../Components/SharedUtils/: NonLIB_sharedUtils.c
  group LIB
    ../../../Libs/CB_Lib/: CBU5000V210_UWB_LIB.lib
    ../../../Libs/BLE_Lib/: CBU5000V210_REGULATED_LIB.lib
  group memory map
    ./Listings/: CBU5000V210.map
  group Device
    ./ARMCM33_DSP_FP/: ARMCM33_ac6.sct
    ../../../Components/ArmCore/Device/ARMCM33_DSP_FP/: startup_ARMCM33.c system_ARMCM33.c
  group ftm
    ../../../Components/Midlayer/Ftm/: ftm_uwb_cal.c ftm_handler.c ftm_cal_nvm.c
  group bin
    ../../../Components/Lut/: lut_bin.s
